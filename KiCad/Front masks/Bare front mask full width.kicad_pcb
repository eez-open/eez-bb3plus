File: KiCad/Front masks/Bare front mask full width.kicad_pcb (KiCad board)
At the start: 2 copper layers, 35 x 111.5 mm, 7 parts

Commit message: #5, #6
Parts:
- moved G*** 0.90 mm to (157.5, 93.5)
